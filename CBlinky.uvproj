# Keil uVision project CBlinky.uvproj, settings and files
target ADuC7128 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ADuC7126 Analog Devices
  cpu: IRAM(0x40000-0x47FFF) IROM(0x80000-0x9F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: CBlinky
  c flags: Optim=1 v6Lang=1 v6LangP=1
  library: MicroLIB
  memory RVCT4: ROM 0x80000 size 0x1f800
  memory RVCT9: RAM 0x40000 size 0x8000
  group Startup Code
    ./: ADuC712x.s
  group Source Code
    ./: main.c Retarget.c irq_arm.c
