# Keil uVision project 7126_Base.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: ADuC7126 Analog Devices
  cpu: IRAM(0x40000-0x47FFF) IROM(0x80000-0x9F7FF) CLOCK(32768) CPUTYPE(ARM7TDMI)
  output: 7126_I2C_Master +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x80000 size 0x1f800
  memory RVCT9: RAM 0x40000 size 0x8000
  group Source Group 1
    ./: ADuC712x.s I2CTestMaster.c
    C:/Keil_v5/ARM/INC/ADI/: ADuC7126.h
